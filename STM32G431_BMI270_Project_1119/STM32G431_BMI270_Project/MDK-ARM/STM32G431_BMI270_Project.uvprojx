# Keil uVision project STM32G431_BMI270_Project.uvprojx, settings and files
target STM32G431_BMI270_Project (6210000::V6.21::ARMCLANG)
  device: STM32G431CBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32G431_BMI270_Project +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G431xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../HAL_Driver/Inc;../Sensor_API/BMI270/Inc;../Sensor_API/CAN/Inc;..\Sensor_API\iDCU_Hill_Control\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c fdcan.c spi.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_fdcan.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Sensro_API
    ../Sensor_API/BMI270/Src/: bmi270.c bmi270_config_file.c idcu_api.c angle_calc.c
    ../Sensor_API/CAN/Src/: can_api.c
  group HAL_Driver
    ../HAL_Driver/Src/: spi_driver.c usart_driver.c
  group iDCU_Hill_Control
    ../Sensor_API/iDCU_Hill_Control/Src/: idcu_hill_descent_assist.c idcu_hill_start_assist.c idcu_vehicle_start_opt.c idcu_falling_security_protection.c
software components: CMSIS:CORE 6.1.0
